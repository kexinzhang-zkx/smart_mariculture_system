# Keil uVision project pro.uvprojx, settings and files
target project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CMSIS;..\DEVICE_LIB\inc;..\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../CMSIS/: startup_stm32f10x_hd.s core_cm3.h
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c
  group SYSTEM
    ../SYSTEM/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group USER
    ./: main.c stm32f10x_it.c
